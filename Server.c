#include "puf.h"
#include "authentication.h"
#include "hkdf.h"
#include "cipher.h"
#include "utils.h"
#include <stdio.h>
#include <time.h>

unsigned const int __attribute__((section(".version"))) optiboot_version = 2049U;
//uint8_t __attribute__((section(".noinit"))) bss_puf[PUF_SIZE];

int main(void)
{
    srand(time(NULL));
    uint8_t key[16U] = {0xB6, 0xD9, 0x33, 0xAC, 0x9B, 0x85, 0x27, 0x7B, 0x83, 0x1A, 0x75, 0xAD, 0x5C, 0x70, 0xD4, 0x88};
    uint8_t id[4U] = {0U};
    uint8_t prk[16U];
    uint8_t ninit[6];
    uint8_t bss_puf[304] = {0xE6, 0xDF, 0x7F, 0xD8, 0x9F, 0x39, 0x2B, 0xFF, 0x29, 0xBF, 0xE7, 0x21, 0x7D, 0x8F, 0xED, 0xAC, 0x43, 0x0E, 0xBE, 0x31, 0x4F, 0xFB, 0x7D, 0xD5, 0x23, 0xED, 0xFE, 0x97, 0x32, 0xCF, 0x7B, 0xBA, 0xB2, 0xE5, 0x0D, 0x95, 0xFD, 0xEE, 0xFE, 0xEB, 0xFC, 0x32, 0x33, 0x75, 0x5D, 0xAF, 0xEA, 0xBD, 0x77, 0x9D, 0xAF, 0xF5, 0xBB, 0x94, 0xDF, 0xD7, 0x3B, 0x62, 0x2F, 0x8B, 0x9D, 0x8F, 0xBB, 0x3E, 0x2F, 0xBF, 0x4B, 0x1D, 0xFD, 0x72, 0xF9, 0x3F, 0xF6, 0x9B, 0xB9, 0xC1, 0x3F, 0xB2, 0x05, 0x06, 0xA6, 0xBE, 0x3E, 0xD6, 0xFE, 0xFE, 0xF4, 0xD3, 0xDF, 0xDD, 0xD1, 0xFE, 0xAF, 0x36, 0xF6, 0x25, 0xA5, 0x96, 0x20, 0x1F, 0x5D, 0xAD, 0xB1, 0x56, 0x03, 0x91, 0x4D, 0xDE, 0x09, 0x1F, 0x34, 0xB6, 0xDD, 0x37, 0x9D, 0xE3, 0x09, 0x9B, 0xE7, 0x53, 0x9F, 0xE5, 0x6E, 0xF0, 0x55, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x36, 0x09, 0xDF, 0xE4, 0xBD, 0xE1, 0xAD, 0x11, 0x66, 0x17, 0x8D, 0xD0, 0xA9, 0x81, 0x30, 0xAE, 0x3B, 0xD1, 0x8B, 0xC7, 0x15, 0xBD, 0x98, 0x1F, 0xB7, 0x4E, 0xFC, 0x2A, 0xF7, 0x28, 0xA1, 0xC6, 0x1A, 0x0D, 0x7B, 0x02, 0xA5, 0x07, 0xAA, 0xE5, 0x4B, 0x9D, 0xB4, 0xD9, 0xCB, 0x12, 0x9F, 0x76, 0x93, 0x14, 0xA1, 0x6C, 0xC1, 0x1D, 0x20, 0xD8, 0xB0, 0x38, 0xA2, 0xBC, 0xFC, 0xE8, 0x46, 0x5F, 0x22, 0x54, 0x27, 0xA5, 0x74, 0xFF, 0x3F, 0xB9, 0x96, 0x52, 0x9E, 0xC7, 0xFD, 0x75, 0xA4, 0xA7, 0xF7, 0x8B, 0x9E, 0x1E, 0x8F, 0x7E, 0x9F, 0x7E, 0x16, 0xD7, 0x14, 0x69, 0xB1, 0xAA, 0x41, 0xEA, 0xBC, 0xD5, 0xDC, 0x03, 0x52, 0xDD, 0x72, 0x48, 0x02, 0xC9, 0x76, 0xF2, 0xE9, 0x49, 0x6E, 0xB5, 0x73, 0x61, 0xCE, 0xF0, 0x72, 0x17, 0x82, 0x13, 0xC4, 0xBE, 0x6D, 0x3C, 0x3E, 0xB5, 0x35, 0x84, 0x15, 0x21, 0xA2, 0x5A, 0xD4, 0xCE, 0xC3, 0xEC, 0x7A, 0x60, 0x3A, 0xBC, 0xAE, 0x00, 0x4D, 0xC3, 0xED, 0x3D, 0xCE};


    // Inserire id da input
    printf("Inserire ID(8 hex)\n");
    inserisci(id, 4);
    printf("ID:");
    stampa(id, 4);
    // Inserire ninit da input
    printf("Inserire Ninit(12 hex)\n");
    inserisci(ninit, 6);
    printf("Ninit:");
    stampa(ninit, 6);

    printf("INFO:Key:");
    //puf_extract(bss_puf, key);
    stampa(key, 16);

    int result;
    // Genero chiave per la cifratura dalla master key
    result = hkdf(SHA256, NULL, 0, key, FE_KEY_SIZE, ninit, sizeof(ninit), prk, FE_KEY_SIZE);
    // Check for errors
    if (result != 0)
    {
        printf("HKDF failed with error %d\n", result);
        return 1;
    }
    printf("INFO:PRK:");
    stampa(prk, 16);

    uint8_t ns[6] = {0U};
    genera(ns, 6);
    printf("Ns:");
    stampa(ns, 6);
    uint8_t msg[sizeof(id) + sizeof(ninit) + sizeof(ns)];
    memcpy(msg, id, sizeof(id));
    memcpy(msg + sizeof(id), ninit, sizeof(ninit));
    memcpy(msg + sizeof(id) + sizeof(ninit), ns, sizeof(ns));
    printf("INFO:Messaggio : ");
    stampa(msg, sizeof(msg));
    Encrypt(msg, prk);
    printf("Messaggio cifrato : ");
    stampa(msg, sizeof(msg));

    // MAC
    // concatena informazioni nel messaggio
    uint8_t ma[sizeof(msg) + sizeof(key) + sizeof(ns)];
    for (int i = 0; i < sizeof(msg); i++)
    {
        ma[i] = msg[i];
    }
    for (int i = 0; i < sizeof(key); i++)
    {
        ma[i + sizeof(msg)] = key[i];
    }
    for (int i = 0; i < sizeof(ns); i++)
    {
        ma[i + sizeof(msg) + sizeof(key)] = ns[i];
    }
    printf("INFO:Messaggio prima del mac\n");
    stampa(ma, sizeof(ma));

    // Lunghezza digest 32 per sha256
    uint8_t digest[32U];
    result = hmac(SHA256, ma, sizeof(ma), key, sizeof(key), digest);
    // Check for errors
    if (result != 0)
    {
        printf("HMAC failed with error %d\n", result);
        return 1;
    }
    // mac(message||k||ns)
    printf("Digest mac\n");
    stampa(digest, sizeof(digest));
    // 4
    uint8_t ms[16];
    printf("Inserisci Ms\n");
    inserisci(ms, 16);

    uint8_t oldDigest[32U];
    printf("Inserisci Mac(Ms,Na)\n");
    inserisci(oldDigest, 32);

    Decrypt(ms, prk);
    // Estrai na con ms=(id,ns,na)
    uint8_t na[6];
    for (int i = 0; i < sizeof(na); i++)
    {
        na[i] = ms[i + sizeof(id) + sizeof(ns)];
    }
    printf("INFO:Na\n");
    stampa(na, sizeof(na));

    // mac (ms,na)
    uint8_t mac[sizeof(ms) + sizeof(na)];
    Encrypt(ms,prk);
    for (int i = 0; i < sizeof(ms); i++)
    {
        mac[i] = ms[i];
    }
    for (int i = 0; i < sizeof(na); i++)
    {
        mac[i + sizeof(ms)] = na[i];
    }
    printf("INFO:Messaggio prima del mac\n");
    stampa(mac, sizeof(mac));

    // Lunghezza digest 32 per sha256
    uint8_t digest3[32U];
    result = hmac(SHA256, mac, sizeof(mac), key, sizeof(key), digest3);
    // Check for errors
    if (result != 0)
    {
        printf("HMAC failed with error %d\n", result);
        return 1;
    }
    // mac(message||na)
    printf("INFO:Digest3 mac\n");
    stampa(digest3, sizeof(digest3));

    // Compara mac
    result = 1;
    for (uint8_t i = 0U; (i < 32U) && result; i++)
    {
        result = (digest3[i] == oldDigest[i]);
    }
    if (result == 1)
    {
        printf("Mac verificato, autenticazione completata\n");
    }
    else
    {
        printf("Mac non autenticato\n");
    }
    return 0;
}